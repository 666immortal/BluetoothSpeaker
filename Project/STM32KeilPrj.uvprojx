# Keil uVision project STM32KeilPrj.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32KeilPrj +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\App\Main;..\App\LED;..\App\DataType;..\HW\RCC;..\HW\Timer;..\HW\UART;..\FW\inc;..\ARM\NVIC;..\ARM\SysTick;..\ARM\System;..\App\Malloc;..\App\SDIO;..\App\SysIT;..\App\FatFs;..\App\FatFs\option;..\App\W25Qxx;..\App\ExFsFun;..\App\DbgFat;..\App\CheckLineFeed;..\App\DbgAsst;..\App\ProcString;..\App\OLED;..\App\TEXT;..\HW\SPI2;..\HW\RTC;..\App\Lamp;..\App\TouchKey;..\App\KEY;..\HW\BitBand;..\HW\WKUP;..\App\VS10xx;..\HW\SPI1;..\OS\MusicPlayer;..\OS\UI;..\HW\PWM;..\HW\ADC;..\HW\AudioSel;..\HW\UART2;..\OS\ExeCode
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group App
    ../App/Main/: Main.c
    ../App/LED/: LED.c
    ../App/Malloc/: Malloc.c
    ../App/SDIO/: SDIO.c
    ../App/SysIT/: SysIT.c
    ../App/FatFs/: ff.c diskio.c
    ../App/FatFs/option/: cc936.c
    ../App/W25Qxx/: W25Qxx.c
    ../App/ExFsFun/: ExFsFun.c
    ../App/DbgFat/: DbgFat.c
    ../App/CheckLineFeed/: CheckLineFeed.c
    ../App/DbgAsst/: DbgAsst.c
    ../App/ProcString/: ProcString.c
    ../App/TEXT/: FontUpd.c Text.c
    ../App/OLED/: OLED.c
    ../App/Lamp/: Lamp.c
    ../App/TouchKey/: TouchKey.c
    ../App/KEY/: KeyOne.c ProcKeyOne.c
    ../App/VS10xx/: VS10xx.c
  group HW
    ../HW/RCC/: RCC.c
    ../HW/Timer/: Timer.c
    ../HW/UART/: UART.c
    ../HW/SPI2/: SPI2.c
    ../HW/RTC/: RTC.c
    ../HW/WKUP/: WakeUp.c
    ../HW/SPI1/: SPI1.c
    ../HW/PWM/: PWM.c
    ../HW/ADC/: ADC.c
    ../HW/AudioSel/: AudioSel.c
    ../HW/UART2/: UART2.c
  group OS
    ../OS/MusicPlayer/: MusicPlayer.c
    ../OS/UI/: UI.c
    ../OS/ExeCode/: ExeCode.c
  group FW
    ../FW/src/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_sdio.c stm32f10x_fsmc.c stm32f10x_dma.c stm32f10x_spi.c stm32f10x_bkp.c stm32f10x_rtc.c stm32f10x_pwr.c stm32f10x_exti.c stm32f10x_adc.c
  group ARM
    ../ARM/NVIC/: NVIC.c
    ../ARM/SysTick/: SysTick.c
    ../ARM/System/: core_cm3.c stm32f10x_it.c system_stm32f10x.c startup_stm32f10x_hd.s
